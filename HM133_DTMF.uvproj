# Keil uVision project HM133_DTMF.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F531 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(25000000)
  output: HM133dtmf +hex
  c flags: Optimize=8
  group Source Group 1
    ./: STARTUP.A51 main.c INIT.A51 f300_init.c sine_c.c
